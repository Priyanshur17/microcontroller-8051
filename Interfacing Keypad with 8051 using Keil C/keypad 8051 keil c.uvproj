# Keil uVision project keypad 8051 keil c.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: keypad 8051 keil c +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: keypad.c
    ../LCD interfacing with 8051 using Keil C/Header File/: lcd.h
