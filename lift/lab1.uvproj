# Keil uVision project lab1.uvproj, settings and files
target Target 1 (MCS-51)
  device: N78E517A Nuvoton
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM=(0x-0xFFFF) CLOCK(40000000)
  output: lab1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: lab2.c
